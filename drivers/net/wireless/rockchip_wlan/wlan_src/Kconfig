## drivers/net/wireless/rockchip_wlan/wlan_src/Kconfig
```kconfig
config RTL8821CS
	tristate "Realtek 8821C SDIO WiFi"
	default m
	help
	  Help message of RTL8821CS
```
